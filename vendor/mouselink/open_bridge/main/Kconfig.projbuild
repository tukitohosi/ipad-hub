## vendor/mouselink/open_bridge/main/Kconfig.projbuild
```kconfig
menu "Application"

config APP_BLE_DEVICE_NAME
    string "BLE device name"
    default "MouseLink-iPad"

endmenu
```
